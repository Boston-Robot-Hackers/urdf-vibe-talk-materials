Commit message: added more examples

File: urdf-examples/makers_pet_loki/mp.urdf (robot description, URDF)
Before this commit: robot makerspet_loki, 11 links, 10 joints
Links:
- link head_link: geometry collision cylinder length=${head_height} radius=${base_diameter/2}
